# Keil uVision project GPIO_LED.uvprojx, settings and files
target GPIO_LED (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPIO_LED +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx
  c include: .\Drivers\STM32L4xx_HAL_Driver\Inc;.\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;.\Drivers\CMSIS\Device\ST\STM32L4xx\Include;.\Drivers\CMSIS\Include;.\USER\Inc;.\Drivers\STM32L476_BSP\GPIO\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User
    ./USER/Src/: main.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Drivers/STM32L4xx_HAL_Driver
    ./Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_i2c.c stm32l4xx_hal_dma.c stm32l4xx_hal_cortex.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_pwr.c
  group Drivers/CMSIS
    ./USER/Src/: system_stm32l4xx.c
  group Drivers/STM32L476_BSP
    ./Drivers/STM32L476_BSP/GPIO/Src/: gpio.c
software components: CMSIS:CORE 5.1.1
